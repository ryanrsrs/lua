## Kconfig
```kconfig
config LUA
	bool "Support for Lua library"
	help
	  This option enables the 'lua' library
```
